# Repository rubengr/ic880a-backplane

## KiCad design backplane.kicad_pcb

Board: 2 copper layers, 93.9 x 83.8 mm, 40 parts (0 on the bottom side), 33 nets.

Parts:
C1, C3: C; C_1206
C2: C; CAP_UNMARKED
D1, D2, D3: LED_Small; LED_1206
D4, D6: D; DO-214AC
D5: D_TVS; DO-214AA
F1: Polyfuse; C_1812
J1, J2: I2C; header_1x5_unmarked
J3: SER; header_1x2_unmarked
J4, J5: PWR; TerminalBlock_Pheonix_MPT-2.54mm_2pol
J6: FAN; header_1x2_marked
Q1, Q2, Q3, Q4: Q_NMOS_GSD; SOT-23
Q5: Q_PMOS_GSD; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R9, R13: R; R_1206
R10, R11, R12: R; R_0805
SW1: SW_Push; SW_Mikroshop
U1: Raspberry_Pi_2_3; Pin_Header_Straight_2x20_Pitch2.54mm
U2: IC880A-SPI
U3: SHT21
U4: MP1584_MODULE
U5: MCP3425A0T-E/CH; SOT-23-6

Connections:
3.3V: C1.2, J1.4, J2.4, R1.2, R2.2, R3.2, R4.1, R5.1, U1.1, U1.17, U3.5, U5.5
5V: D4.1, D5.1, J1.5, J2.5, J6.2, Q5.2, R10.1, U1.2, U1.4, U2.21
BTN: SW1.1, U1.32
CE0: U1.24, U2.17
CLK: U1.23, U2.14
FAN: Q4.1, R9.2, U1.12
GND: C1.1, C2.1, D5.2, J1.3, J2.3, J4.1, Q1.2, Q2.2, Q3.2, Q4.2, R6.2, R7.2, R8.2, R9.1, R12.2, R13.1, SW1.2, U1.9, U1.14, U1.20, U1.25, U1.30, U1.34, U1.39, U2.1, U2.12, U2.20, U2.22, U2.24, U3.2, U4.4, U5.2
GPS_RST: U1.29, U2.3
GPS_SUP: U1.31, U2.5
IC880A_RST: U1.22, U2.13
LED1: Q1.1, R6.1, U1.40
LED2: Q2.1, R7.1, U1.38
LED3: Q3.1, R8.1, U1.36
MISO: U1.21, U2.15
MOSI: U1.19, U2.16
unnamed: C2.2, D6.2, F1.1, J4.2, U4.3
unnamed: C3.1, R11.2, R12.1, U5.6
unnamed: C3.2, R10.2, R11.1, U5.1
unnamed: D1.1, Q1.3
unnamed: D1.2, R1.1
unnamed: D2.1, Q2.3
unnamed: D2.2, R2.1
unnamed: D3.1, Q3.3
unnamed: D3.2, R3.1
unnamed: D4.2, J6.1, Q4.3
unnamed: D6.1, J5.2, U4.2
unnamed: F1.2, Q5.3
unnamed: J5.1, U4.1
unnamed: Q5.1, R13.2
RX: J3.2, U1.10
SCL: J1.2, J2.2, R5.2, U1.5, U3.6, U5.3
SDA: J1.1, J2.1, R4.2, U1.3, U3.1, U5.4
TX: J3.1, U1.8

## Commit log

2017-09-29 Remove labels
